<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>proba_receiver</value></param>
<param><key>title</key><value>Receiver for CONV/RS encoded BPSK frames as used in Proba</value></param>
<param><key>author</key><value>Martin Luelf</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
<param><key>config_file</key><value>config_file</value></param>
<param><key>section</key><value>USRP</value></param>
<param><key>option</key><value>gain</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>ASM_enc_tail</value></param>
<param><key>value</key><value>12</value></param>
<param><key>type</key><value>int</value></param>
<param><key>config_file</key><value>config_file</value></param>
<param><key>section</key><value>Signal</value></param>
<param><key>option</key><value>ASM_enc_tail</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>frame_len_dec</value></param>
<param><key>value</key><value>223</value></param>
<param><key>type</key><value>int</value></param>
<param><key>config_file</key><value>config_file</value></param>
<param><key>section</key><value>Signal</value></param>
<param><key>option</key><value>frame_len_dec</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>ASM</value></param>
<param><key>value</key><value>1ACFFC1D</value></param>
<param><key>type</key><value>string</value></param>
<param><key>config_file</key><value>config_file</value></param>
<param><key>section</key><value>Signal</value></param>
<param><key>option</key><value>ASM_dec</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>lo_offset</value></param>
<param><key>value</key><value>2.5*samp_rate</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>2e9</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>config_file</value></param>
<param><key>section</key><value>USRP</value></param>
<param><key>option</key><value>freq</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>osf</value></param>
<param><key>value</key><value>4</value></param>
<param><key>type</key><value>int</value></param>
<param><key>config_file</key><value>config_file</value></param>
<param><key>section</key><value>USRP</value></param>
<param><key>option</key><value>oversampling</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(freq,lo_offset)</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>ant0</key><value></value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>signal_rate</value></param>
<param><key>value</key><value>2e6</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>config_file</value></param>
<param><key>section</key><value>Signal</value></param>
<param><key>option</key><value>sig_rate</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>ASM_enc_len</value></param>
<param><key>value</key><value>52</value></param>
<param><key>type</key><value>int</value></param>
<param><key>config_file</key><value>config_file</value></param>
<param><key>section</key><value>Signal</value></param>
<param><key>option</key><value>ASM_enc_len</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>mpsk_demod_soft</key>
<param><key>id</key><value>mpsk_demod_soft_1_0</value></param>
<param><key>alpha</key><value>0.5</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>M</key><value>2</value></param>
<param><key>osf</key><value>osf</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_1_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>signal_rate</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>config_file</value></param>
<param><key>label</key><value>config</value></param>
<param><key>value</key><value>/home/ngs1/martin_luelf_test/sync_test/proba_receiver_proba1.conf</value></param>
<param><key>type</key><value>string</value></param>
<param><key>short_id</key><value>c</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_len_enc</value></param>
<param><key>value</key><value>frame_len_dec*2*255/223</value></param>
</block>
<block>
<key>ccsds_conv_decode27</key>
<param><key>id</key><value>ccsds_conv_decode27_0_0</value></param>
<param><key>gen_poly_c1</key><value>0x79</value></param>
<param><key>gen_poly_c2</key><value>0xDB</value></param>
<param><key>punct</key><value>NONE</value></param>
<param><key>num_bits_out</key><value>frame_len_enc/2*8</value></param>
<param><key>ASM</key><value>ASM</value></param>
</block>
<block>
<key>ccsds_rs_decode</key>
<param><key>id</key><value>ccsds_rs_decode_0</value></param>
<param><key>I</key><value>5</value></param>
</block>
<block>
<key>gr_message_debug</key>
<param><key>id</key><value>gr_message_debug_0</value></param>
</block>
<block>
<key>gr_file_source</key>
<param><key>id</key><value>gr_file_source_0</value></param>
<param><key>file</key><value>/home/ngs1/adc_out/2013.04.08.08.49.25.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>osf*signal_rate</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate*2</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>ASM_enc</value></param>
<param><key>value</key><value>81C971AA73D3E0</value></param>
<param><key>type</key><value>string</value></param>
<param><key>config_file</key><value>config_file</value></param>
<param><key>section</key><value>Signal</value></param>
<param><key>option</key><value>ASM_enc</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>ccsds_mpsk_ambiguity_resolver_f</key>
<param><key>id</key><value>ccsds_mpsk_ambiguity_resolver_f_1</value></param>
<param><key>M</key><value>2</value></param>
<param><key>ASM</key><value>ASM_enc</value></param>
<param><key>ASM_len</key><value>ASM_enc_len</value></param>
<param><key>threshold</key><value>1</value></param>
<param><key>corr_threshold</key><value>0.6</value></param>
<param><key>frame_len</key><value>frame_len_enc</value></param>
<param><key>num_tail_sym</key><value>ASM_enc_tail</value></param>
</block>
<connection><source_block_id>mpsk_demod_soft_1_0</source_block_id><sink_block_id>ccsds_mpsk_ambiguity_resolver_f_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>mpsk_demod_soft_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>mpsk_demod_soft_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_mpsk_ambiguity_resolver_f_1</source_block_id><sink_block_id>ccsds_conv_decode27_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_mpsk_ambiguity_resolver_f_1</source_block_id><sink_block_id>gr_message_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_conv_decode27_0_0</source_block_id><sink_block_id>ccsds_rs_decode_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_rs_decode_0</source_block_id><sink_block_id>gr_message_debug_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
</flow_graph>

options:
  parameters:
    author: Martin Luelf
    description: Take Doppler corrected baseband recording and decode the signal blocks within. The decoded blocks are saved with metadata in a detached header file.
    generate_options: no_gui
    id: move2_postprocessing
    output_language: python
    run_options: run
    title: MOVE-II recording post processing
  states: {}

blocks:
- name: constellation_ccsds
  id: variable_constellation_ccsds
  parameters:
    comment: MOVE-II downlink modulation (BPSK)
    type: bpsk
  states: {}
- name: frame_gen_config
  id: variable_frame_generation_config
  parameters:
    comment: Look for previous frames, include all detected blocks.
    numafter: '0'
    numbefore: '5'
    thresholdprimary: '0.0'
    thresholdsecondary: '0.0'
  states: {}
- name: frame_sync_config
  id: variable_frame_sync_config
  parameters:
    constellation: constellation_ccsds
    num_head_bits: '0'
    num_tail_bits: '0'
    payload_len_bits: int(1024*2)
    sync_marker: '''49E0DCC7'''
    sync_num_bits: '32'
  states: {}
- name: osf
  id: variable
  parameters:
    comment: Oversampling factor before the timing synchronization (>= 2)
    value: int(input_rate/symbol_rate)
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    comment: MOVE-II downlink symbol rate
    value: 12.5e3
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_agc_xx_0_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_file_meta_sink_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'True'
    extra_dict: pmt.make_dict()
    file: output_file
    max_seg_size: '1000000'
    rel_rate: input_rate/symbol_rate
    samp_rate: input_rate
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_meta_source_0
  id: blocks_file_meta_source
  parameters:
    detached: 'True'
    file: input_file
    hdr_file: input_file+'.hdr'
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    comment: Switch between old and new frame sync block
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: frame_sync
    type: complex
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    name: source
    type: complex
  states: {}
- name: ccsds_blob_msg_source_b_0
  id: ccsds_blob_msg_source_b
  parameters:
    blob_len: '128'
    length_tag_name: packet_len
  states: {}
- name: ccsds_frame_sync_0
  id: ccsds_frame_sync
  parameters:
    additional_frames: ccsds.asm_position_list()
    gen_config: frame_gen_config
    sync_config: frame_sync_config
  states: {}
- name: ccsds_ldpc_decoder_0
  id: ccsds_ldpc_decoder
  parameters:
    drop_invalid: 'False'
    num_punct: '512'
    par_file: /opt/GnuRadio/AR4JA_r12_k1024n.a
    punct_pos: '[]'
    puncttype: punct_back
    systype: sys_front
    verbosity: ccsds.DECODER_VERBOSITY_QUIET
  states: {}
- name: ccsds_mpsk_ambiguity_resolver_f_0
  id: ccsds_mpsk_ambiguity_resolver_f
  parameters:
    ASM: '''49E0DCC7'''
    ASM_len: '32'
    M: '8'
    corr_threshold: '0.8'
    frame_len: 2*128
    num_tail_sym: '0'
    threshold: '1'
  states: {}
- name: ccsds_mpsk_detector_soft_cf_0
  id: ccsds_mpsk_detector_soft_cf
  parameters:
    M: '2'
  states: {}
- name: ccsds_randomiser_softbits_0
  id: ccsds_randomiser_softbits
  parameters:
    poly: '0x95'
    seed: '0xFF'
  states: {}
- name: ccsds_soft_to_hard_message_0
  id: ccsds_soft_to_hard_message
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.05'
    gain_omega: '0.1'
    mu: '0.25'
    omega: osf
    omega_relative_limit: '0.01'
    type: complex
  states: {}
- name: digital_costas_loop_cc_1
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    use_snr: 'True'
    w: pi/100.0
  states: {}
- name: digital_probe_mpsk_snr_est_c_0
  id: digital_probe_mpsk_snr_est_c
  parameters:
    alpha: '0.001'
    msg_nsamples: '10000'
    type: '0'
  states: {}
- name: frame_sync
  id: parameter
  parameters:
    comment: |-
      0: Use old M-PSK Ambiguity Resolver with Softbits (CCSDS) block
      1: Use new Frame Sync block
    hide: part
    label: frame_sync
    type: intx
    value: '1'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from cmath import pi
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import pmt
  states: {}
- name: input_file
  id: parameter
  parameters:
    label: input
    short_id: i
    type: str
    value: ''
  states: {}
- name: input_rate
  id: parameter
  parameters:
    label: input_rate
    short_id: r
    type: eng_float
    value: 25e3
  states: {}
- name: output_file
  id: parameter
  parameters:
    label: output
    short_id: o
    type: str
    value: ''
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    decim: '1'
    gain: '1'
    ntaps: 50*osf+1
    samp_rate: input_rate
    sym_rate: symbol_rate
    type: fir_filter_ccf
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: symbols_filtered
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: decoded_pdus
  states: {}
- name: virtual_sink_0_0_1
  id: virtual_sink
  parameters:
    stream_id: detected_pdus
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: symbols_synced
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: symbols_synced
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: decoded_pdus
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: detected_pdus
  states: {}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: symbols_filtered
  states: {}

connections:
- [analog_agc_xx_0, '0', root_raised_cosine_filter_0, '0']
- [analog_agc_xx_0_0, '0', virtual_sink_0_1, '0']
- [blocks_file_meta_source_0, '0', analog_agc_xx_0, '0']
- [blocks_file_meta_source_0, '0', blocks_tag_debug_0, '0']
- [blocks_selector_0, '0', ccsds_mpsk_detector_soft_cf_0, '0']
- [blocks_selector_0, '1', ccsds_frame_sync_0, '0']
- [ccsds_blob_msg_source_b_0, '0', blocks_file_meta_sink_0, '0']
- [ccsds_frame_sync_0, out, virtual_sink_0_0_1, '0']
- [ccsds_ldpc_decoder_0, out, virtual_sink_0_0, '0']
- [ccsds_mpsk_ambiguity_resolver_f_0, out, virtual_sink_0_0_1, '0']
- [ccsds_mpsk_detector_soft_cf_0, '0', ccsds_mpsk_ambiguity_resolver_f_0, '0']
- [ccsds_randomiser_softbits_0, out, ccsds_ldpc_decoder_0, in]
- [ccsds_soft_to_hard_message_0, out, ccsds_blob_msg_source_b_0, in]
- [digital_clock_recovery_mm_xx_0, '0', analog_agc_xx_0_0, '0']
- [digital_costas_loop_cc_1, '0', digital_clock_recovery_mm_xx_0, '0']
- [digital_probe_mpsk_snr_est_c_0, noise, digital_costas_loop_cc_1, noise]
- [root_raised_cosine_filter_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', blocks_selector_0, '0']
- [virtual_source_0_0, '0', ccsds_soft_to_hard_message_0, in]
- [virtual_source_0_0_0, '0', ccsds_randomiser_softbits_0, in]
- [virtual_source_0_1_0, '0', digital_costas_loop_cc_1, '0']
- [virtual_source_0_1_0, '0', digital_probe_mpsk_snr_est_c_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-510-g2180acce

options:
  parameters:
    author: k4kdr
    generate_options: qt_gui
    id: decode_MOVE_II_k4kdr
    output_language: python
    title: decode_MOVE_II_k4kdr
  states: {}

blocks:
- name: BFO
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-40000'
    step: '100'
    stop: '40000'
    value: '-10300'
  states: {state: disabled}
- name: Center_Freq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-20000'
    step: '50'
    stop: '20000'
    value: '9050'
  states: {}
- name: Filter_BW
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '5000'
    step: '50'
    stop: '20000'
    value: '12000'
  states: {}
- name: Filter_Slope
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '100'
    step: '50'
    stop: '10000'
    value: '2400'
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: samp_rate/symbol_rate
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    comment: |-
      Best?  76800


      data_sideband_freq/symbol_rate_multiplier


      data_sideband_freq/symbol_rate_multiplier/decimation

      64000
    value: '12500'
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: BFO
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/move-ii.bin
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /tmp/move2-single-packet-222_78125.raw
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '32767'
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '128'
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    comment: input from GQRX or 48k .wav file streamer
    eof: 'False'
    ipaddr: 127.0.0.1
    port: '7355'
    psize: '1472'
    type: short
    vlen: '1'
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /tmp/N6RFM_center-9050_AUDIO.wav
    repeat: 'False'
  states: {}
- name: ccsds_blob_msg_sink_b_0
  id: ccsds_blob_msg_sink_b
  parameters:
    blob_len: '128'
  states: {}
- name: ccsds_ldpc_decoder_0
  id: ccsds_ldpc_decoder
  parameters:
    drop_invalid: 'False'
    num_punct: '512'
    par_file: /home/k4kdr/gr-ccsds/examples/move2_postprocessing/AR4JA_r12_k1024n.a
    punct_pos: '[]'
    puncttype: punct_back
    systype: sys_front
    verbosity: ccsds.DECODER_VERBOSITY_QUIET
  states: {}
- name: ccsds_message_info_0
  id: ccsds_message_info
  parameters:
    mode: ccsds.MESSAGE_INFO_COMPACT
    prefix: '"Message info: "'
  states: {}
- name: ccsds_mpsk_ambiguity_resolver_f_0
  id: ccsds_mpsk_ambiguity_resolver_f
  parameters:
    ASM: '''49E0DCC7'''
    ASM_len: '32'
    M: '2'
    corr_threshold: '0.8'
    frame_len: '256'
    num_tail_sym: '0'
    threshold: '1'
  states: {}
- name: ccsds_randomiser_softbits_0
  id: ccsds_randomiser_softbits
  parameters:
    poly: '0x95'
    seed: '0xFF'
  states: {}
- name: ccsds_softbits_msg_to_bytes_b_0
  id: ccsds_softbits_msg_to_bytes_b
  parameters: {}
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    comment: |-
      ORIG:  order = 2

      ORIG:  Loop bw = 0.01

      loop_bw
    order: '2'
    w: ' 0.01'
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.01'
    max_dev: '0.01'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: samp_per_sym
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: Center_Freq
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate,Filter_BW, Filter_Slope)
    type: fcf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import ccsds.util
  states: {}
- name: import_0_0_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0_0_0
  id: import
  parameters:
    imports: import fractions
  states: {}
- name: import_0_0_1
  id: import
  parameters:
    imports: import cmath
  states: {}
- name: note_1_0_0_0_0_0_0
  id: note
  parameters:
    note: 'run:  direwolf -p'
  states: {}
- name: note_1_0_0_0_0_0_0_0
  id: note
  parameters:
    note: Enable for SatNogs
  states: {}
- name: note_1_0_0_0_0_0_0_0_0
  id: note
  parameters:
    note: '!! Set File Path !!'
  states: {}
- name: note_1_0_0_0_0_0_0_0_0_0
  id: note
  parameters:
    note: Raw I/Q File Input
  states: {}
- name: note_1_0_0_0_0_0_0_0_0_0_0
  id: note
  parameters:
    note: Audio File Input
  states: {}
- name: note_1_0_0_0_0_0_0_0_0_0_0_0
  id: note
  parameters:
    note: Manual Freq Adj.
  states: {}
- name: note_1_0_0_0_0_0_0_0_0_1
  id: note
  parameters:
    note: AR4JA_r12_k1024n.a
  states: {}
- name: note_3_0_1_0_0_0
  id: note
  parameters:
    note: GQRX udp audio Input
  states: {}
- name: note_3_0_1_0_0_0_0
  id: note
  parameters:
    note: Input to BEACONPARSER
  states: {}
- name: note_3_0_1_0_0_0_0_0
  id: note
  parameters:
    note: ./beaconparser -7 -8 -r -i80 /tmp/move-ii.bin
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    color1: '"Dark Blue"'
    comment: int(tlm_symbol_rate/10)
    legend: 'False'
    name: BPSK Constellation
    size: int(symbol_rate/10)
    type: complex
    xmax: '3'
    xmin: '-3'
    ymax: '3'
    ymin: '-3'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/2
    fc: '0'
    fftsize: '1024'
    name: '"Original"'
    showports: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '20'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Centered"'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '20'
  states: {}
- name: satellites_hexdump_sink_1
  id: satellites_hexdump_sink
  parameters: {}
  states: {}
- name: satellites_kiss_file_sink_0_0_1_0_0
  id: satellites_kiss_file_sink
  parameters:
    file: /tmp/kisstnc
  states: {}
- name: satellites_print_timestamp_0_0
  id: satellites_print_timestamp
  parameters:
    count: 'True'
    fmt: '%Y-%m-%d %H:%M:%S'
  states: {}
- name: satellites_rms_agc_0_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-3'
    comment: '1e-2'
    reference: '1.0'
  states: {}
- name: satellites_telemetry_submit_0
  id: satellites_telemetry_submit
  parameters:
    comment: '"--start_time ''2023-04-26T15:29:00''"'
    norad: '43780'
    options: ''
    server: '"SatNOGS"'
  states: {state: disabled}
- name: satnogs_ogg_source_0
  id: satnogs_ogg_source
  parameters:
    channels: '1'
    filename: /tmp/satnogs_8755937_2023-12-23T20-44-32.ogg
    repeat: 'False'
  states: {state: disabled}

connections:
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_1, '1']
- [blocks_complex_to_real_0, '0', ccsds_mpsk_ambiguity_resolver_f_0, '0']
- [blocks_file_source_0, '0', blocks_multiply_xx_1, '0']
- [blocks_multiply_xx_1, '0', blocks_throttle_0_0, '0']
- [blocks_short_to_float_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_short_to_float_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, satellites_kiss_file_sink_0_0_1_0_0, in]
- [blocks_tagged_stream_to_pdu_0, pdus, satellites_print_timestamp_0_0, in]
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_throttle_0_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [blocks_throttle_0_0, '0', satellites_rms_agc_0_0, '0']
- [blocks_udp_source_0, '0', blocks_short_to_float_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle_0, '0']
- [ccsds_blob_msg_sink_b_0, out, ccsds_message_info_0, in]
- [ccsds_ldpc_decoder_0, out, ccsds_softbits_msg_to_bytes_b_0, in]
- [ccsds_mpsk_ambiguity_resolver_f_0, out, ccsds_randomiser_softbits_0, in]
- [ccsds_randomiser_softbits_0, out, ccsds_ldpc_decoder_0, in]
- [ccsds_softbits_msg_to_bytes_b_0, '0', blocks_file_sink_0_0, '0']
- [ccsds_softbits_msg_to_bytes_b_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [ccsds_softbits_msg_to_bytes_b_0, '0', ccsds_blob_msg_sink_b_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_complex_to_real_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_symbol_sync_xx_0_0, '0', digital_costas_loop_cc_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', satellites_rms_agc_0_0, '0']
- [satellites_print_timestamp_0_0, out, satellites_hexdump_sink_1, in]
- [satellites_print_timestamp_0_0, out, satellites_telemetry_submit_0, in]
- [satellites_rms_agc_0_0, '0', digital_symbol_sync_xx_0_0, '0']
- [satnogs_ogg_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1

<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>sample_ccsds_receiver</value></param>
<param><key>author</key><value>Martin Luelf</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>Example receiver for CONV/RS encoded M-PSK frames as used in Proba</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_len_enc</value></param>
<param><key>value</key><value>frame_len_dec*2*255/223</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ldM</value></param>
<param><key>value</key><value>int(math.log(M)/math.log(2))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>osf*signal_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sym_rate</value></param>
<param><key>value</key><value>samp_rate/osf</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ASM</value></param>
<param><key>label</key><value>Attached sync marker</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>1ACFFC1D</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ASM_enc</value></param>
<param><key>label</key><value>Convolutional encoded ASM</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>81C971AA73D3E0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ASM_enc_len</value></param>
<param><key>label</key><value>Number of constant bits in encoded ASM sequence</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>52</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ASM_enc_tail</value></param>
<param><key>label</key><value>Number of tail bits (for Conv decoding)</value></param>
<param><key>short_id</key><value>t</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>12</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>M</value></param>
<param><key>label</key><value>Modulation order</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>alpha</value></param>
<param><key>label</key><value>Rollof factor</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.5</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0</value></param>
<param><key>attack_rate</key><value>1e-1</value></param>
<param><key>decay_rate</key><value>1e-2</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>0.0</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0_0</value></param>
<param><key>attack_rate</key><value>1e-1</value></param>
<param><key>decay_rate</key><value>1e-2</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>0.0</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>ccsds_conv_decode27</key>
<param><key>id</key><value>ccsds_conv_decode27_0_0</value></param>
<param><key>gen_poly_c1</key><value>0x79</value></param>
<param><key>gen_poly_c2</key><value>0xDB</value></param>
<param><key>num_bits_out</key><value>frame_len_enc/2*8</value></param>
<param><key>punct</key><value>NONE</value></param>
<param><key>ASM</key><value>ASM</value></param>
</block>
<block>
<key>ccsds_mpsk_ambiguity_resolver_f</key>
<param><key>id</key><value>ccsds_mpsk_ambiguity_resolver_f_1</value></param>
<param><key>ASM_len</key><value>ASM_enc_len</value></param>
<param><key>corr_threshold</key><value>0.6</value></param>
<param><key>frame_len</key><value>frame_len_enc</value></param>
<param><key>threshold</key><value>1</value></param>
<param><key>M</key><value>M</value></param>
<param><key>ASM</key><value>ASM_enc</value></param>
<param><key>num_tail_sym</key><value>ASM_enc_tail</value></param>
</block>
<block>
<key>ccsds_mpsk_detector_soft_cf</key>
<param><key>id</key><value>ccsds_mpsk_detector_soft_cf_0</value></param>
<param><key>M</key><value>M</value></param>
</block>
<block>
<key>ccsds_randomiser</key>
<param><key>id</key><value>ccsds_randomiser_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>poly</key><value>0x95</value></param>
<param><key>seed</key><value>0xFF</value></param>
</block>
<block>
<key>ccsds_rs_decode</key>
<param><key>id</key><value>ccsds_rs_decode_0</value></param>
<param><key>repr</key><value>0</value></param>
<param><key>I</key><value>5</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>gain_omega</key><value>0.25*0.175*0.175</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>omega</key><value>osf*(1+0.0)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0</value></param>
<param><key>w</key><value>1e-3</value></param>
<param><key>order</key><value>M</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>frame_len_dec</value></param>
<param><key>label</key><value>Frame length (without encoding)</value></param>
<param><key>short_id</key><value>l</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>223</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>Signal centre frequency</value></param>
<param><key>short_id</key><value>f</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2.28e9</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>Internal gain of the USRP</value></param>
<param><key>short_id</key><value>g</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>Raised cosine matched filter. Bypass one for Square root cosine and both for no matched filter.</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>note</key><value>RF settings</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2</value></param>
<param><key>note</key><value>Signal configuration</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_3</value></param>
<param><key>note</key><value>Computation of constants</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_4</value></param>
<param><key>note</key><value>ASM</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>osf</value></param>
<param><key>label</key><value>Oversampling factor</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>root_raised_cosine_filter</key>
<param><key>id</key><value>root_raised_cosine_filter_0_1_0_0</value></param>
<param><key>alpha</key><value>alpha</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>interp</key><value>osf</value></param>
<param><key>ntaps</key><value>11*osf</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sym_rate</key><value>sym_rate</value></param>
</block>
<block>
<key>root_raised_cosine_filter</key>
<param><key>id</key><value>root_raised_cosine_filter_0_1_0_0_0</value></param>
<param><key>alpha</key><value>alpha</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>interp</key><value>osf</value></param>
<param><key>ntaps</key><value>11*osf</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sym_rate</key><value>sym_rate</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>signal_rate</value></param>
<param><key>label</key><value>Nominal data rate (without oversampling)</value></param>
<param><key>short_id</key><value>r</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>int(2e6)</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>analog_agc2_xx_0</source_block_id><sink_block_id>ccsds_mpsk_detector_soft_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc2_xx_0_0</source_block_id><sink_block_id>root_raised_cosine_filter_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_conv_decode27_0_0</source_block_id><sink_block_id>ccsds_randomiser_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ccsds_mpsk_ambiguity_resolver_f_1</source_block_id><sink_block_id>ccsds_conv_decode27_0_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ccsds_mpsk_detector_soft_cf_0</source_block_id><sink_block_id>ccsds_mpsk_ambiguity_resolver_f_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_randomiser_0</source_block_id><sink_block_id>ccsds_rs_decode_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ccsds_rs_decode_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>analog_agc2_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0_1_0_0</source_block_id><sink_block_id>root_raised_cosine_filter_0_1_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0_1_0_0_0</source_block_id><sink_block_id>digital_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>analog_agc2_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>

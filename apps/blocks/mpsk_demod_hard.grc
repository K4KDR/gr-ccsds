<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>parameter</key>
<param><key>id</key><value>alpha</value></param>
<param><key>label</key><value>Rollof factor</value></param>
<param><key>value</key><value>0.5</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>short_id</key><value>R</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_osf_0</value></param>
<param><key>note</key><value>samp_rate / osf</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sym_rate</value></param>
<param><key>value</key><value>samp_rate/osf</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>M</value></param>
<param><key>label</key><value>Modulation Order</value></param>
<param><key>value</key><value>4</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>short_id</key><value>M</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>osf</value></param>
<param><key>label</key><value>Samples per Symbol</value></param>
<param><key>value</key><value>4</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>ccsds_local_oscillator_cc</key>
<param><key>id</key><value>ccsds_local_oscillator_cc_0</value></param>
<param><key>L</key><value>4</value></param>
<param><key>osf</key><value>osf</value></param>
</block>
<block>
<key>root_raised_cosine_filter</key>
<param><key>id</key><value>root_raised_cosine_filter_0_1_0_0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>interp</key><value>osf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sym_rate</key><value>sym_rate</value></param>
<param><key>alpha</key><value>alpha</value></param>
<param><key>ntaps</key><value>11*osf</value></param>
</block>
<block>
<key>root_raised_cosine_filter</key>
<param><key>id</key><value>root_raised_cosine_filter_0_1_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>interp</key><value>osf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sym_rate</key><value>sym_rate</value></param>
<param><key>alpha</key><value>alpha</value></param>
<param><key>ntaps</key><value>11*osf</value></param>
</block>
<block>
<key>root_raised_cosine_filter</key>
<param><key>id</key><value>root_raised_cosine_filter_0_1_0_0_0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>interp</key><value>osf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sym_rate</key><value>sym_rate</value></param>
<param><key>alpha</key><value>alpha</value></param>
<param><key>ntaps</key><value>11*osf</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ldM</value></param>
<param><key>value</key><value>int(math.log(M)/math.log(2))</value></param>
</block>
<block>
<key>ccsds_dll_cc</key>
<param><key>id</key><value>ccsds_dll_cc_0</value></param>
<param><key>osf</key><value>osf</value></param>
<param><key>gamma</key><value>0.1</value></param>
</block>
<block>
<key>gr_throttle</key>
<param><key>id</key><value>gr_throttle_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>sym_rate</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>attack_rate</key><value>1e-1</value></param>
<param><key>decay_rate</key><value>1e-2</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>0.0</value></param>
</block>
<block>
<key>ccsds_pll_cc</key>
<param><key>id</key><value>ccsds_pll_cc_0</value></param>
<param><key>M</key><value>M</value></param>
<param><key>BL</key><value>0.5</value></param>
</block>
<block>
<key>ccsds_mpsk_demod_cb</key>
<param><key>id</key><value>ccsds_mpsk_demod_cb_0</value></param>
<param><key>M</key><value>M</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>out</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>mpsk_demod_hard</value></param>
<param><key>title</key><value>M-PSK Hardbit Demodulation Chain</value></param>
<param><key>author</key><value>Martin Luelf</value></param>
<param><key>description</key><value>A block for synchronization and demodulation of M-PSK signals using hard bit decisions.</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>CCSDS</value></param>
</block>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>ccsds_local_oscillator_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_pll_cc_0</source_block_id><sink_block_id>ccsds_local_oscillator_cc_0</sink_block_id><source_key>msg</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0_1_0_0_0</source_block_id><sink_block_id>ccsds_dll_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_local_oscillator_cc_0</source_block_id><sink_block_id>root_raised_cosine_filter_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0_1_0_0</source_block_id><sink_block_id>root_raised_cosine_filter_0_1_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_local_oscillator_cc_0</source_block_id><sink_block_id>root_raised_cosine_filter_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0_1_0</source_block_id><sink_block_id>ccsds_dll_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_dll_cc_0</source_block_id><sink_block_id>gr_throttle_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_throttle_0_0_0</source_block_id><sink_block_id>analog_agc2_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc2_xx_0</source_block_id><sink_block_id>ccsds_pll_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_pll_cc_0</source_block_id><sink_block_id>ccsds_mpsk_demod_cb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_mpsk_demod_cb_0</source_block_id><sink_block_id>out</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>

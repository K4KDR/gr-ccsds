<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ccsds_channel</value></param>
<param><key>author</key><value>Martin Luelf</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>CCSDS channel</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ASM</value></param>
<param><key>value</key><value>'1ACFFC1D'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>M</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>alpha</value></param>
<param><key>value</key><value>0.5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_len_dec</value></param>
<param><key>value</key><value>223*5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_len_enc</value></param>
<param><key>value</key><value>frame_len_dec*1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_rate</value></param>
<param><key>value</key><value>bit_rate/(frame_len_dec*8.0)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>2.2e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ldM</value></param>
<param><key>value</key><value>int(math.log(M)/math.log(2))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>lo_offset</value></param>
<param><key>value</key><value>2.5*samp_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>osf</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>bit_rate*((frame_len_enc+(len(ASM)/2.0))/frame_len_dec)*2.0*osf/ldM</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>soft_quant</value></param>
<param><key>value</key><value>7</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_recv_ip</value></param>
<param><key>value</key><value>'192.168.20.2'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_send_ip</value></param>
<param><key>value</key><value>'192.168.10.2'</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0</value></param>
<param><key>attack_rate</key><value>1e-1</value></param>
<param><key>decay_rate</key><value>1e-2</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>65536</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bit_rate</value></param>
<param><key>label</key><value>Bit rate in bits per second</value></param>
<param><key>short_id</key><value>r</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>int(1e6)</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>ccsds_add_asm</key>
<param><key>id</key><value>ccsds_add_asm_0</value></param>
<param><key>frame_len</key><value>frame_len_enc</value></param>
<param><key>ASM</key><value>ASM</value></param>
</block>
<block>
<key>ccsds_blob_msg_source_b</key>
<param><key>id</key><value>ccsds_blob_msg_source_b_0</value></param>
<param><key>blob_len</key><value>frame_len_enc+len(ASM)/2</value></param>
</block>
<block>
<key>ccsds_conv_decode27</key>
<param><key>id</key><value>ccsds_conv_decode27_0</value></param>
<param><key>gen_poly_c1</key><value>0x79</value></param>
<param><key>gen_poly_c2</key><value>0xDB</value></param>
<param><key>num_bits_out</key><value>frame_len_enc*8</value></param>
<param><key>punct</key><value>NONE</value></param>
<param><key>ASM</key><value>ASM</value></param>
</block>
<block>
<key>ccsds_conv_encode27_bb</key>
<param><key>id</key><value>ccsds_conv_encode27_bb_0</value></param>
<param><key>gen_poly_c1</key><value>0x79</value></param>
<param><key>gen_poly_c2</key><value>0xDB</value></param>
<param><key>punct</key><value>NONE</value></param>
</block>
<block>
<key>ccsds_mpsk_ambiguity_resolver_f</key>
<param><key>id</key><value>ccsds_mpsk_ambiguity_resolver_f_0</value></param>
<param><key>ASM_len</key><value>52</value></param>
<param><key>corr_threshold</key><value>0.8</value></param>
<param><key>frame_len</key><value>frame_len_enc*2</value></param>
<param><key>threshold</key><value>1</value></param>
<param><key>M</key><value>M</value></param>
<param><key>ASM</key><value>ASM_enc</value></param>
<param><key>num_tail_sym</key><value>12</value></param>
</block>
<block>
<key>ccsds_mpsk_detector_soft_cf</key>
<param><key>id</key><value>ccsds_mpsk_detector_soft_cf_0</value></param>
<param><key>M</key><value>M</value></param>
</block>
<block>
<key>ccsds_mpsk_mod_bc</key>
<param><key>id</key><value>ccsds_mpsk_mod_bc_0</value></param>
<param><key>M</key><value>M</value></param>
</block>
<block>
<key>ccsds_rs_decode</key>
<param><key>id</key><value>ccsds_rs_decode_0</value></param>
<param><key>repr</key><value>0</value></param>
<param><key>I</key><value>5</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>epsilon</key><value>1.0</value></param>
<param><key>freq_offset</key><value>0.0</value></param>
<param><key>noise_voltage</key><value>0.0</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>1.0 + 1.0j</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>gain_omega</key><value>0.25*0.175*0.175</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>omega</key><value>osf*(1+0.0)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0</value></param>
<param><key>w</key><value>1e-3</value></param>
<param><key>order</key><value>M</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>note</key><value>Real USRP channel</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>note</key><value>Simulated channel</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>num_frames</value></param>
<param><key>label</key><value>Number of Frames</value></param>
<param><key>short_id</key><value>n</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>port_in</value></param>
<param><key>label</key><value>Input port number</value></param>
<param><key>short_id</key><value>i</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1736</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>port_out</value></param>
<param><key>label</key><value>Output port number</value></param>
<param><key>short_id</key><value>o</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1739</value></param>
</block>
<block>
<key>ticp_frame_sink</key>
<param><key>id</key><value>ticp_frame_sink_0</value></param>
<param><key>data_type</key><value>0</value></param>
<param><key>frame_len</key><value>5*223</value></param>
<param><key>mapping</key><value>{}</value></param>
<param><key>port</key><value>port_out</value></param>
</block>
<block>
<key>ticp_frame_source</key>
<param><key>id</key><value>ticp_frame_source_0</value></param>
<param><key>data_type</key><value>0</value></param>
<param><key>frame_len</key><value>5*223</value></param>
<param><key>hostname</key><value>localhost</value></param>
<param><key>frame_rate</key><value>0.0</value></param>
<param><key>mapping</key><value>{}</value></param>
<param><key>port</key><value>port_in</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>'ip=' + usrp_send_ip</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>analog_agc2_xx_0</source_block_id><sink_block_id>digital_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>analog_agc2_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_add_asm_0</source_block_id><sink_block_id>ccsds_blob_msg_source_b_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ccsds_blob_msg_source_b_0</source_block_id><sink_block_id>ccsds_conv_encode27_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_conv_decode27_0</source_block_id><sink_block_id>ccsds_rs_decode_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ccsds_conv_encode27_bb_0</source_block_id><sink_block_id>ccsds_mpsk_mod_bc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_mpsk_ambiguity_resolver_f_0</source_block_id><sink_block_id>ccsds_conv_decode27_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ccsds_mpsk_detector_soft_cf_0</source_block_id><sink_block_id>ccsds_mpsk_ambiguity_resolver_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_mpsk_mod_bc_0</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_mpsk_mod_bc_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_rs_decode_0</source_block_id><sink_block_id>ticp_frame_sink_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>ccsds_mpsk_detector_soft_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ticp_frame_source_0</source_block_id><sink_block_id>ccsds_add_asm_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>analog_agc2_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>

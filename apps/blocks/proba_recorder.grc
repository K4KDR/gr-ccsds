<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>proba_recorder</value></param>
<param><key>title</key><value>Record samples received from a proba pass</value></param>
<param><key>author</key><value>Martin Luelf</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>signal_rate</value></param>
<param><key>value</key><value>5e5</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>config_file</value></param>
<param><key>section</key><value>Signal</value></param>
<param><key>option</key><value>sig_rate</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>lo_offset</value></param>
<param><key>value</key><value>2.5*samp_rate</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>osf</value></param>
<param><key>value</key><value>4</value></param>
<param><key>type</key><value>int</value></param>
<param><key>config_file</key><value>config_file</value></param>
<param><key>section</key><value>USRP</value></param>
<param><key>option</key><value>oversampling</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>config_file</value></param>
<param><key>label</key><value>config</value></param>
<param><key>value</key><value>/home/ngs1/martin_luelf_test/sync_test/proba_receiver_proba1.conf</value></param>
<param><key>type</key><value>string</value></param>
<param><key>short_id</key><value>c</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>2.236e9</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>config_file</value></param>
<param><key>section</key><value>USRP</value></param>
<param><key>option</key><value>freq</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>output_file</value></param>
<param><key>label</key><value>outfile</value></param>
<param><key>value</key><value>proba1_recorder_out2.dat</value></param>
<param><key>type</key><value>string</value></param>
<param><key>short_id</key><value>o</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from datetime import datetime</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>file_path</value></param>
<param><key>value</key><value>"/home/ngs1/adc_out/"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>file_out</value></param>
<param><key>value</key><value>file_path + datetime.now().strftime("%Y.%m.%d.%H.%M.%S") + ".dat"</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>20</value></param>
<param><key>type</key><value>int</value></param>
<param><key>config_file</key><value>config_file</value></param>
<param><key>section</key><value>USRP</value></param>
<param><key>option</key><value>gain</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>freq</value></param>
<param><key>bw</key><value>samp_rate</value></param>
</block>
<block>
<key>gr_file_sink</key>
<param><key>id</key><value>gr_file_sink_0</value></param>
<param><key>file</key><value>file_out</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>unbuffered</key><value>False</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>osf*signal_rate</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value>addr=192.168.20.2</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>ant0</key><value></value></param>
<param><key>bw0</key><value>5*samp_rate</value></param>
</block>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>gr_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>

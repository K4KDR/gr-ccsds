<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>h_receiver</value></param>
<param><key>title</key><value>GSRF reference signal receiver</value></param>
<param><key>author</key><value>Martin Luelf</value></param>
<param><key>description</key><value>receive the GSRF reference signal from the H-building</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>alpha</value></param>
<param><key>value</key><value>0.5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>M</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>gr_file_sink</key>
<param><key>id</key><value>gr_file_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/tmp/dll_in</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>unbuffered</key><value>False</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>10000</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>int(2e6)</value></param>
</block>
<block>
<key>gr_file_source</key>
<param><key>id</key><value>gr_file_source_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/tmp/dll_in</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sym_rate</value></param>
<param><key>value</key><value>samp_rate/osf</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value>addr=192.168.20.2</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>clock_source0</key><value>internal</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>2.26e9</value></param>
<param><key>gain0</key><value>25</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>bw0</key><value>30e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>10e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>osf</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>cutoff_freq</key><value>1.5*sym_rate</value></param>
<param><key>width</key><value>0.5*sym_rate</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>ccsds_dll_cc</key>
<param><key>id</key><value>ccsds_dll_cc_0</value></param>
<param><key>osf</key><value>osf</value></param>
<param><key>gamma</key><value>0.5</value></param>
</block>
<block>
<key>ccsds_mpsk_ambiguity_resolver_f</key>
<param><key>id</key><value>ccsds_mpsk_ambiguity_resolver_f_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>M</key><value>M</value></param>
<param><key>ASM</key><value>81C971AA73D3E0</value></param>
<param><key>ASM_len</key><value>52</value></param>
<param><key>threshold</key><value>1</value></param>
<param><key>corr_threshold</key><value>0.6</value></param>
<param><key>frame_len</key><value>2550</value></param>
<param><key>num_tail_sym</key><value>12</value></param>
</block>
<block>
<key>ccsds_mpsk_detector_soft_cf</key>
<param><key>id</key><value>ccsds_mpsk_detector_soft_cf_0</value></param>
<param><key>M</key><value>M</value></param>
</block>
<block>
<key>ccsds_softbits_msg_to_bytes_b</key>
<param><key>id</key><value>ccsds_softbits_msg_to_bytes_b_0</value></param>
</block>
<block>
<key>ccsds_blob_msg_sink_b</key>
<param><key>id</key><value>ccsds_blob_msg_sink_b_0</value></param>
<param><key>blob_len</key><value>1111</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>ccsds_mpsk_ambiguity_resolver_f</key>
<param><key>id</key><value>ccsds_mpsk_ambiguity_resolver_f_1</value></param>
<param><key>M</key><value>M</value></param>
<param><key>ASM</key><value>1ACFFC1D</value></param>
<param><key>ASM_len</key><value>32</value></param>
<param><key>threshold</key><value>1</value></param>
<param><key>corr_threshold</key><value>0.6</value></param>
<param><key>frame_len</key><value>1111</value></param>
<param><key>num_tail_sym</key><value>0</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>attack_rate</key><value>1e-2</value></param>
<param><key>decay_rate</key><value>1e-2</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>100.0</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
</block>
<block>
<key>ccsds_pll_cc</key>
<param><key>id</key><value>ccsds_pll_cc_0</value></param>
<param><key>M</key><value>M</value></param>
<param><key>BL</key><value>0.0005</value></param>
</block>
<block>
<key>ccsds_local_oscillator_cc</key>
<param><key>id</key><value>ccsds_local_oscillator_cc_0</value></param>
<param><key>L</key><value>100</value></param>
<param><key>osf</key><value>osf</value></param>
</block>
<connection><source_block_id>ccsds_pll_cc_0</source_block_id><sink_block_id>ccsds_mpsk_detector_soft_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>gr_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0</source_block_id><sink_block_id>blocks_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_dll_cc_0</source_block_id><sink_block_id>ccsds_pll_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_file_source_0</source_block_id><sink_block_id>ccsds_dll_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>analog_agc2_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc2_xx_0</source_block_id><sink_block_id>ccsds_local_oscillator_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_local_oscillator_cc_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>ccsds_dll_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_mpsk_detector_soft_cf_0</source_block_id><sink_block_id>ccsds_mpsk_ambiguity_resolver_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_mpsk_ambiguity_resolver_f_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_mpsk_detector_soft_cf_0</source_block_id><sink_block_id>ccsds_mpsk_ambiguity_resolver_f_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_pll_cc_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_mpsk_ambiguity_resolver_f_1</source_block_id><sink_block_id>ccsds_softbits_msg_to_bytes_b_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_softbits_msg_to_bytes_b_0</source_block_id><sink_block_id>ccsds_blob_msg_sink_b_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_blob_msg_sink_b_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ccsds_pll_cc_0</source_block_id><sink_block_id>ccsds_local_oscillator_cc_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
</flow_graph>

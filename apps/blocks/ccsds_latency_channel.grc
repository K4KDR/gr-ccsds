<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ccsds_latency_channel</value></param>
<param><key>title</key><value>Channel for latency measurements</value></param>
<param><key>author</key><value>Martin Luelf</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>alpha</value></param>
<param><key>value</key><value>0.5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_recv_ip</value></param>
<param><key>value</key><value>'192.168.20.2'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>lo_offset</value></param>
<param><key>value</key><value>2.5*samp_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_send_ip</value></param>
<param><key>value</key><value>'192.168.10.2'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>2.2e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ldM</value></param>
<param><key>value</key><value>int(math.log(M)/math.log(2))</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>soft_quant</value></param>
<param><key>value</key><value>7</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ASM</value></param>
<param><key>value</key><value>'1ACFFC1D'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ASM_enc</value></param>
<param><key>value</key><value>'81C971AA73D3E0'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_len_dec</value></param>
<param><key>value</key><value>223*5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_len_enc</value></param>
<param><key>value</key><value>frame_len_dec*255/223</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>M</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>osf</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>ccsds_add_asm</key>
<param><key>id</key><value>ccsds_add_asm_0</value></param>
<param><key>ASM</key><value>ASM</value></param>
<param><key>frame_len</key><value>frame_len_enc</value></param>
</block>
<block>
<key>ccsds_rs_encode</key>
<param><key>id</key><value>ccsds_rs_encode_0</value></param>
<param><key>I</key><value>5</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>port_in</value></param>
<param><key>label</key><value>Input port number</value></param>
<param><key>value</key><value>1736</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>short_id</key><value>i</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>port_out</value></param>
<param><key>label</key><value>Output port number</value></param>
<param><key>value</key><value>1739</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>short_id</key><value>o</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>num_frames</value></param>
<param><key>label</key><value>Number of Frames</value></param>
<param><key>value</key><value>1000</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>short_id</key><value>n</value></param>
</block>
<block>
<key>ccsds_blob_msg_source_b</key>
<param><key>id</key><value>ccsds_blob_msg_source_b_0</value></param>
<param><key>blob_len</key><value>frame_len_enc+len(ASM)/2</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>note</key><value>Channel</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value>'ip=' + usrp_send_ip</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(freq,lo_offset)</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(freq,lo_offset)</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>ant0</key><value>RX2</value></param>
</block>
<block>
<key>gr_throttle</key>
<param><key>id</key><value>gr_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>mpsk_demod_soft</key>
<param><key>id</key><value>mpsk_demod_soft_1</value></param>
<param><key>alpha</key><value>0.5</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>M</key><value>M</value></param>
<param><key>osf</key><value>osf</value></param>
</block>
<block>
<key>ccsds_mpsk_ambiguity_resolver_f</key>
<param><key>id</key><value>ccsds_mpsk_ambiguity_resolver_f_0</value></param>
<param><key>M</key><value>M</value></param>
<param><key>ASM</key><value>ASM_enc</value></param>
<param><key>ASM_len</key><value>52</value></param>
<param><key>threshold</key><value>1</value></param>
<param><key>corr_threshold</key><value>0.8</value></param>
<param><key>frame_len</key><value>frame_len_enc*2</value></param>
<param><key>num_tail_sym</key><value>12</value></param>
</block>
<block>
<key>ccsds_conv_decode27</key>
<param><key>id</key><value>ccsds_conv_decode27_0</value></param>
<param><key>gen_poly_c1</key><value>0x79</value></param>
<param><key>gen_poly_c2</key><value>0xDB</value></param>
<param><key>punct</key><value>NONE</value></param>
<param><key>num_bits_out</key><value>frame_len_enc*8</value></param>
<param><key>ASM</key><value>ASM</value></param>
</block>
<block>
<key>ccsds_rs_decode</key>
<param><key>id</key><value>ccsds_rs_decode_0</value></param>
<param><key>I</key><value>5</value></param>
</block>
<block>
<key>ccsds_ticp_frame_sink</key>
<param><key>id</key><value>ccsds_ticp_frame_sink_0</value></param>
<param><key>port</key><value>port_out</value></param>
<param><key>frame_len</key><value>frame_len_dec</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bit_rate</value></param>
<param><key>label</key><value>Bit rate in bits per second</value></param>
<param><key>value</key><value>int(1e6)</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>short_id</key><value>r</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>bit_rate*((frame_len_enc+(len(ASM)/2.0))/frame_len_dec)*2.0*osf/ldM</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_rate</value></param>
<param><key>value</key><value>bit_rate/(frame_len_dec*8.0)</value></param>
</block>
<block>
<key>gr_head</key>
<param><key>id</key><value>gr_head_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>int((frame_len_enc+len(ASM)/2.0)*num_frames)</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>ccsds_conv_encode27_bb</key>
<param><key>id</key><value>ccsds_conv_encode27_bb_0</value></param>
<param><key>gen_poly_c1</key><value>0x79</value></param>
<param><key>gen_poly_c2</key><value>0xDB</value></param>
<param><key>punct</key><value>NONE</value></param>
</block>
<block>
<key>gr_channel_model</key>
<param><key>id</key><value>gr_channel_model_0</value></param>
<param><key>noise_voltage</key><value>0.00</value></param>
<param><key>freq_offset</key><value>0/samp_rate</value></param>
<param><key>epsilon</key><value>1.0</value></param>
<param><key>taps</key><value>1.0 </value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>ccsds_ticp_frame_source</key>
<param><key>id</key><value>ccsds_ticp_frame_source_0</value></param>
<param><key>hostname</key><value>localhost</value></param>
<param><key>port</key><value>port_in</value></param>
<param><key>frame_len</key><value>frame_len_dec</value></param>
<param><key>frame_rate</key><value>frame_rate</value></param>
</block>
<block>
<key>mpsk_mod</key>
<param><key>id</key><value>mpsk_mod_0_0</value></param>
<param><key>osf</key><value>osf</value></param>
<param><key>M</key><value>M</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>alpha</key><value>alpha</value></param>
<param><key>preamble_len</key><value>0</value></param>
</block>
<connection><source_block_id>ccsds_add_asm_0</source_block_id><sink_block_id>ccsds_blob_msg_source_b_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_rs_encode_0</source_block_id><sink_block_id>ccsds_add_asm_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_ticp_frame_source_0</source_block_id><sink_block_id>ccsds_rs_encode_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_blob_msg_source_b_0</source_block_id><sink_block_id>gr_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_throttle_0</source_block_id><sink_block_id>mpsk_demod_soft_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_head_0</source_block_id><sink_block_id>ccsds_conv_encode27_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>mpsk_demod_soft_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_channel_model_0</source_block_id><sink_block_id>gr_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_mpsk_ambiguity_resolver_f_0</source_block_id><sink_block_id>ccsds_conv_decode27_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mpsk_demod_soft_1</source_block_id><sink_block_id>ccsds_mpsk_ambiguity_resolver_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_conv_decode27_0</source_block_id><sink_block_id>ccsds_rs_decode_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_rs_decode_0</source_block_id><sink_block_id>ccsds_ticp_frame_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_conv_encode27_bb_0</source_block_id><sink_block_id>mpsk_mod_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mpsk_mod_0_0</source_block_id><sink_block_id>gr_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>

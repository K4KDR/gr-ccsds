<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>mpsk_mod</value></param>
<param><key>title</key><value>M-PSK Modulation Chain</value></param>
<param><key>author</key><value>Martin Luelf</value></param>
<param><key>description</key><value>A block for modulation and signal forming of an M-PSK signal.</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>CCSDS</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>osf</value></param>
<param><key>label</key><value>Samples per Symbol</value></param>
<param><key>value</key><value>4</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_osf_0_0</value></param>
<param><key>note</key><value>Data Source</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_osf_0_0_0_2</value></param>
<param><key>note</key><value>Symbol Bits</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_osf_0_0_0</value></param>
<param><key>note</key><value>Symbol Forming</value></param>
</block>
<block>
<key>gr_packed_to_unpacked_xx</key>
<param><key>id</key><value>gr_packed_to_unpacked_xx_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>bits_per_chunk</key><value>ldM</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>num_ports</key><value>1</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>M</value></param>
<param><key>label</key><value>Modulation Order</value></param>
<param><key>value</key><value>4</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>short_id</key><value>M</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>short_id</key><value>R</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>alpha</value></param>
<param><key>label</key><value>Rollof factor</value></param>
<param><key>value</key><value>0.5</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ldM</value></param>
<param><key>value</key><value>int(math.log(M)/math.log(2))</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_osf_0</value></param>
<param><key>note</key><value>samp_rate / osf</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_osf_0_0_0_3</value></param>
<param><key>note</key><value>Preamble</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_osf_0_0_0_1</value></param>
<param><key>note</key><value>Output Samples</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_osf_0_0_0_0</value></param>
<param><key>note</key><value>Channel Filtering</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>interp_fir_filter_ccf</value></param>
<param><key>interp</key><value>osf</value></param>
<param><key>gain</key><value>osf*0.7</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>cutoff_freq</key><value>sym_rate</value></param>
<param><key>width</key><value>sym_rate</value></param>
<param><key>win</key><value>firdes.WIN_RECTANGULAR</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sym_rate</value></param>
<param><key>value</key><value>samp_rate/osf</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>preamble_len</value></param>
<param><key>label</key><value>Preamble length</value></param>
<param><key>value</key><value>16000</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>ccsds_mpsk_preamble_cc</key>
<param><key>id</key><value>ccsds_mpsk_preamble_cc_0</value></param>
<param><key>num_syms</key><value>preamble_len</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>label</key><value>out</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>ccsds_mpsk_mod_bc</key>
<param><key>id</key><value>ccsds_mpsk_mod_bc_0</value></param>
<param><key>M</key><value>M</value></param>
</block>
<block>
<key>root_raised_cosine_filter</key>
<param><key>id</key><value>root_raised_cosine_filter_0_0</value></param>
<param><key>type</key><value>interp_fir_filter_ccf</value></param>
<param><key>interp</key><value>osf</value></param>
<param><key>gain</key><value>osf*0.7</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sym_rate</key><value>sym_rate</value></param>
<param><key>alpha</key><value>0.5</value></param>
<param><key>ntaps</key><value>11*osf</value></param>
</block>
<connection><source_block_id>ccsds_mpsk_mod_bc_0</source_block_id><sink_block_id>ccsds_mpsk_preamble_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_packed_to_unpacked_xx_0</source_block_id><sink_block_id>ccsds_mpsk_mod_bc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>gr_packed_to_unpacked_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_mpsk_preamble_cc_0</source_block_id><sink_block_id>root_raised_cosine_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_mpsk_preamble_cc_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
